Commit message: add contact force to state vector

File: push-policy/push_policy/resources/car.urdf (robot description, URDF)
Before this commit: robot simplecar, 7 links, 6 joints
Links:
- link base_link: geometry collision box size=0.5 0.3 0.1; visual box size=0.5 0.3 0.1
